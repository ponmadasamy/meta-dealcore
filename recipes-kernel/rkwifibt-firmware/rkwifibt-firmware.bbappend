
SRC_URI = "git://${EXTRA}/rkwifibt;protocol=file;usehead=1"
SRCREV = "${AUTOREV}"
