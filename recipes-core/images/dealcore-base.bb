
DESCRIPTION = "DealCore Base Image"
IMAGE_FEATURES_append = " ssh-server-dropbear"

LICENSE = "MIT"
