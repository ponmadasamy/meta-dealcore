
SRC_URI = "git://${EXTRA}/camera_engine_rkisp;protocol=file;usehead=1"
SRCREV = "${AUTOREV}"