
SRC_URI = "git://${EXTRA}/mpp;protocol=file;usehead=1"
SRCREV = "${AUTOREV}"
