
SRC_URI = "git://${EXTRA}/libv4l-rkmpp;protocol=file;usehead=1"
SRCREV = "${AUTOREV}"