
PACKAGECONFIG_append += "qt5"

SRC_URI_remove += " \
	0001-qtdemux-don-t-skip-the-stream-duration-longer-than-3.patch \
"