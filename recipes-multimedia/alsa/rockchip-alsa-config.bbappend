
SRC_URI = "git://${EXTRA}/alsa-config;protocol=file;usehead=1"
SRCREV = "${AUTOREV}"