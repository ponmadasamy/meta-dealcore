
SRC_URI = "git://${EXTRA}/gstreamer-rockchip;protocol=file;usehead=1"
SRCREV = "${AUTOREV}"