SRC_URI = "http://hiawatha-webserver.org/files/hiawatha-10/${BP}.tar.gz \
           file://hiawatha-init \
           file://hiawatha.service "
