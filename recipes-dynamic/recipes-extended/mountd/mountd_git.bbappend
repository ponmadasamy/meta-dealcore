FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ADD.patch \
            file://0001-ADD-tune.patch \
            "

