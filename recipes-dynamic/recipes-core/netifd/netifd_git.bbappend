SRC_URI_remove = "\
	            file://0001-resolv.conf.auto-Use-run-instead-of-tmp.patch \
            "
