PACKAGECONFIG_append = ""