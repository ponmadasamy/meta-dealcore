
SRC_URI = "git://${EXTRA}/rknpu-fw;protocol=file;usehead=1"
SRCREV = "${AUTOREV}"